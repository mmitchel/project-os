DEPENDS:append:tegra = " virtual/libgbm"
