DEPENDS:append:tegra = " virtual/libgbm"
# Serialize compilation at task level
# do_configure[depends] += "webkitgtk:do_compile"
