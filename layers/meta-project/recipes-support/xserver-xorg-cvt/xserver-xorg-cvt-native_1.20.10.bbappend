FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-xf86Option-rename-bool-union-member-for-newer-C-sta.patch"
