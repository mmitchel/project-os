INSANE_SKIP:${PN}-dev += "buildpaths"
