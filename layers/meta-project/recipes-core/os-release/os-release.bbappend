OS_RELEASE_FIELDS += "MACHINE DISTRO_FEATURES MACHINE_FEATURES"
