require image-project.inc

# Add project packages here as your layer grows.
IMAGE_INSTALL:append = " packagegroup-project-base"
