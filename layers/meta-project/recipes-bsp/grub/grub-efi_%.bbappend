PACKAGECONFIG += "device-mapper"

GRUB_BUILDIN += "all"
